# Keil uVision project LAB_PROJECT.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_PROJECT
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.s SystemTickInit.s ADC_SETUP.s ATD_SAMPLING.s gpio_setup.s init_port_b.s Pulse.s find_dom_freq.s CONVRT.s OutStr.s OutChar.s Timer1_init.s FIND_WHICH.s display_screen.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
